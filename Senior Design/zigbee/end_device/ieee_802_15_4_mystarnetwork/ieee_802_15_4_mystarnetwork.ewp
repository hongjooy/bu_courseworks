# IAR project ieee_802_15_4_mystarnetwork.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: examples/ieee_802_15_4/MyStarNetwork/EndDevice/frdmkw40z/FreeRTOS/app_preinclude.h
  ICCARM.CCIncludePath2: $_KSDK13_FWK524_PATH_$/platform/CMSIS/Include; boards/frdmkw40z; $_KSDK13_FWK524_PATH_$/platform/devices; $_KSDK13_FWK524_PATH_$/platform/devices/MKW40Z4/include; $_KSDK13_FWK524_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK13_FWK524_PATH_$/platform/system/src/clock/MKW40Z4; $_KSDK13_FWK524_PATH_$/../ConnSw/ieee_802_15_4/Source/App; $_KSDK13_FWK524_PATH_$/../ConnSw/ieee_802_15_4/Source/Mac/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/GPIOIrq; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Keyboard/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/LED/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/SerialManager/Source/SPI_Adapter; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Common; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/MemManager/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Messaging/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/OSAbstraction/Interface; $_KSDK13_FWK524_PATH_$/platform/osa/inc; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Panic/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/RNG/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/SerialManager/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/TimersManager/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/TimersManager/Source; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/FunctionLib; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Lists; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/SecLib; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/ModuleInfo; examples/ieee_802_15_4/MyStarNetwork/EndDevice/common; $_KSDK13_FWK524_PATH_$/platform/devices; $_KSDK13_FWK524_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK13_FWK524_PATH_$/rtos/FreeRTOS/include; $_KSDK13_FWK524_PATH_$/rtos/FreeRTOS/port/iar; $_KSDK13_FWK524_PATH_$/rtos/FreeRTOS/config/KW40Z4/iar; $_KSDK13_FWK524_PATH_$/../ConnSw/ieee_802_15_4/Source/Phy/Source/MKW40Z; $_KSDK13_FWK524_PATH_$/../ConnSw/ieee_802_15_4/Source/Phy/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/XCVR/MKW40Z4; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/DCDC/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Flash/Internal; $_KSDK13_FWK524_PATH_$/platform/drivers/src/flash/C90TFS/drvsrc/include; $_KSDK13_FWK524_PATH_$/platform/drivers/inc; $_KSDK13_FWK524_PATH_$/platform/system/inc; $_KSDK13_FWK524_PATH_$/platform/hal/inc; $_KSDK13_FWK524_PATH_$/platform/utilities/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: $_KSDK13_FWK524_PATH_$\rtos\FreeRTOS\config\KW40Z4\iar
  OBJCOPY.OOCOutputFile: ieee_802_15_4_mystarnetwork.bin
  ILINK.IlinkOutputFile: MyStarNetworkEndDevice_FreeRTOS.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK524_PATH_$/../ConnSw/framework/SecLib/lib_crypto_IAR_M0.a; $_KSDK13_FWK524_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\debug\libksdk_platform_freertos.a; $_KSDK13_FWK524_PATH_$/../ConnSw/ieee_802_15_4/Lib/Freescale_802.15.4_MAC_06_M0_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK524_PATH_$/../ConnSw/framework/SecLib/lib_crypto_IAR_M0.a; $_KSDK13_FWK524_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\release\libksdk_platform_freertos.a; $_KSDK13_FWK524_PATH_$/../ConnSw/ieee_802_15_4/Lib/Freescale_802.15.4_MAC_06_M0_IAR.a
  group framework/Common
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Common/: EmbeddedTypes.h FwkInit.c
  group framework/DCDC/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/DCDC/Source/: DCDC.c
  group framework/Flash/Internal
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group framework/FunctionLib
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIOIrq/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/GPIOIrq/: GPIO_IrqAdapter.h
  group framework/GPIOIrq/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/GPIOIrq/: GPIO_IrqAdapter.c
  group framework/Keyboard/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/LED/Source/: LED.c
  group framework/Lists
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Lists/: GenericList.c GenericList.h
  group framework/MemManager/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/ModuleInfo/: ModuleInfo.h
  group framework/OSAbstraction/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/OSAbstraction/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/OSAbstraction/Source/: fsl_osa_ext_freertos.c
  group framework/Panic/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Panic/Source/: Panic.c
  group framework/Reset/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Reset/: Reset.c
  group framework/RNG/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/RNG/Source/: RNG.c
  group framework/SecLib
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/SerialManager/Source/: SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/SerialManager/Source/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group framework/TimersManager/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group framework/XCVR/MKW40Z4
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/XCVR/MKW40Z4/: BLEDefaults.h ifr_mkw40z4_radio.c ifr_mkw40z4_radio.h ifr_tbl_apache_radio.h KW4xXcvrDrv.c KW4xXcvrDrv.h overwrites.h tsm_ll_timing.c tsm_ll_timing.h tsm_timing_ble.h tsm_timing_zigbee.h ZigbeeDefaults.h
  group ieee_802.15.4/App
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/ieee_802_15_4/Source/App/: FsciMacCommands.c FsciMacCommands.h MacGlobals.c MacGlobals.h
  group ieee_802.15.4/Mac/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/ieee_802_15_4/Source/Mac/Interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802.15.4/PHY/Interface
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/ieee_802_15_4/Source/Phy/Interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802.15.4/PHY/Source
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/ieee_802_15_4/Source/Phy/Source/MKW40Z/: ASP.c MPM.c Phy.h PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group KSDK
    boards/frdmkw40z/: accel.c accel.h board_combined.c board_combined.h fsl_i2c_irq.c fsl_lptmr_irq.c fxos_api.c fxos_api.h fxos_def.h gpio_pins_combined.c gpio_pins_combined.h hardware_init_combined.c mma8451_api.c mma8451_api.h pin_mux_combined.c pin_mux_combined.h
  group RTOS/FreeRTOS
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/rtos/FreeRTOS/src/: croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/rtos/FreeRTOS/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/rtos/FreeRTOS/config/KW40Z4/iar/: FreeRTOSConfig.h
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
  group RTOS/FreeRTOS/Startup
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/devices/: startup.c startup.h
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/devices/MKW40Z4/startup/iar/: startup_MKW40Z4.s
    ../../../../../Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/devices/MKW40Z4/startup/: system_MKW40Z4.c system_MKW40Z4.h
  group Source
    examples/ieee_802_15_4/MyStarNetwork/EndDevice/common/: App.c App.h
    examples/ieee_802_15_4/MyStarNetwork/EndDevice/frdmkw40z/FreeRTOS/: app_preinclude.h
